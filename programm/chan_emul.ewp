# IAR project chan_emul.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: source; $TOOLKIT_DIR$\inc\AnalogDevices; FreeRTOS\include; FreeRTOS\portable\IAR\ARM_CM3; FreeRTOS\portable\MemMang
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  AARM.AUserIncludes: FreeRTOS\include
  OBJCOPY.OOCOutputFile: chan_emul.hex
  ILINK.IlinkOutputFile: chan_emul.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 3
  group FreeRtos
    FreeRTOS/include/: FreeRTOSConfig.h
    FreeRTOS/portable/MemMang/: heap_1.c
    FreeRTOS/: list.c queue.c tasks.c
    FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group Programm
    source/: cur_in.c cur_out.c freq_out.c main.c mcu.c modbus.cpp off_out.c serial.cpp startup_ADuCM360.s tc_out.c tr_out.c u_out.c UART_class.cpp
